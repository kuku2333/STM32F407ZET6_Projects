# Keil uVision project project.uvprojx, settings and files
target project (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F407ZETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: project +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F40_41xxx
  c include: ..\DEVICE_LIB\inc;..\CMSIS;..\SYSTEM;..\USER;..\HARDWARE\inc;..\HARDWARE\BEEP;..\HARDWARE\KEY;..\HARDWARE\LCD;..\HARDWARE\LED;..\HARDWARE\TIM;..\HARDWARE\TOUCH;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group SYSTEM
    ../SYSTEM/: stm32f4xx.h system_stm32f4xx.c system_stm32f4xx.h
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group DEVICE_LIB
    ../DEVICE_LIB/src/: misc.c stm32f4xx_rcc.c stm32f4xx_gpio.c stm32f4xx_exti.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_spi.c stm32f4xx_fsmc.c stm32f4xx_dcmi.c stm32f4xx_dma.c
  group CMSIS
    ../CMSIS/: core_cm4.h core_cm4_simd.h core_cmFunc.h core_cmInstr.h startup_stm32f40_41xxx.s
  group HARDWARE
    ../HARDWARE/LCD/: tft.c
    ../HARDWARE/LED/: led.c
    ../HARDWARE/TIM/: tim.c
    ../HARDWARE/TOUCH/: touch.c
  group USER
    ./: main.c stm32f4xx_conf.h stm32f4xx_it.c stm32f4xx_it.h
